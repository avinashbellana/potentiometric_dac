** pdac_schematic **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Avinash
* Fri, Jun 12, 2020 11:55:01
*

*## Multisim Component R8 ##*
rR8 3 0 210 vresR8
.model vresR8 r(  )

*## Multisim Component R6 ##*
rR6 2 0 210 vresR6
.model vresR6 r(  )

*## Multisim Component LED2 ##*
*!!!BEGIN-INTERACT
*  : Ion           ++++f2    ;
*  0.0      VARIABLE   r1Cur
*
*  : LED_OFF
*     1 11 0 SET_SUBCOMP_PRP
*     0 13 0 SET_SUBCOMP_PRP
*     1 12 0 SET_SUBCOMP_PRP
*     0 14 0 SET_SUBCOMP_PRP
*  ;
*
*  : LED_ON
*     0 11 0 SET_SUBCOMP_PRP
*     1 13 0 SET_SUBCOMP_PRP
*     0 12 0 SET_SUBCOMP_PRP
*     1 14 0 SET_SUBCOMP_PRP
*  ;
*
*  :UPDATE_SETTINGS
*     LED_OFF
*  ;
*
*  :OUT_DATA
*     GET_INSTANCE Vsource ::V V  i  ==>_*r1Cur
*     Ion  *r1Cur  0.00004999  f.-   f.<=   if
*        LED_ON
*     else
*        LED_OFF
*     endif
*  ;
*
*  :BEGIN_PLOT
*     LED_OFF
*  ;
*
* !!!END-INTERACT
*
xLED2 D1 3 LED_redLED2
*
.SUBCKT LED_redLED2  K A
D1 1 A  LED_mod
V   K  1  DC 0
.MODEL LED_mod D (
+ IS=1.112e-021 N=3.007e+000 RS=3.513e-003
+ BV=6.100e+001 IBV=6.000e-003
+ EG=1.110e+000 XTI=3.000e+000
+ CJO=3.238e-011, M=3.388e-001 VJ=3.250e-001
+ FC=5.000e-001 KF=0.000e+000 AF=1.000e+000 )
.ENDS

*## Multisim Component LED1 ##*
*!!!BEGIN-INTERACT
*  : Ion           ++++f2    ;
*  0.0      VARIABLE   r1Cur
*
*  : LED_OFF
*     1 11 0 SET_SUBCOMP_PRP
*     0 13 0 SET_SUBCOMP_PRP
*     1 12 0 SET_SUBCOMP_PRP
*     0 14 0 SET_SUBCOMP_PRP
*  ;
*
*  : LED_ON
*     0 11 0 SET_SUBCOMP_PRP
*     1 13 0 SET_SUBCOMP_PRP
*     0 12 0 SET_SUBCOMP_PRP
*     1 14 0 SET_SUBCOMP_PRP
*  ;
*
*  :UPDATE_SETTINGS
*     LED_OFF
*  ;
*
*  :OUT_DATA
*     GET_INSTANCE Vsource ::V V  i  ==>_*r1Cur
*     Ion  *r1Cur  0.00004999  f.-   f.<=   if
*        LED_ON
*     else
*        LED_OFF
*     endif
*  ;
*
*  :BEGIN_PLOT
*     LED_OFF
*  ;
*
* !!!END-INTERACT
*
xLED1 D0 2 LED_redLED1
*
.SUBCKT LED_redLED1  K A
D1 1 A  LED_mod
V   K  1  DC 0
.MODEL LED_mod D (
+ IS=1.112e-021 N=3.007e+000 RS=3.513e-003
+ BV=6.100e+001 IBV=6.000e-003
+ EG=1.110e+000 XTI=3.000e+000
+ CJO=3.238e-011, M=3.388e-001 VJ=3.250e-001
+ FC=5.000e-001 KF=0.000e+000 AF=1.000e+000 )
.ENDS

*## Multisim Component V3 ##*
vV3 D1 0 dc 0
+
+
+ pwlrepeat(0 0 1.9 0 2 5 3.9 5 4 0)

*## Multisim Component V2 ##*
vV2 D0 0 dc 0
+
+
+ pwlrepeat(0 0 0.9 0 1 5 1.9 5 2 0)

*## Multisim Instrument XMM1 ##*
XMM1 Vout 0 XXMM1_127046952

*## Multisim Component Vref ##*
vVref 6 0 dc 5 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component R5 ##*
rR5 17 0 625 vresR5
.model vresR5 r(  )

*## Multisim Component R4 ##*
rR4 16 17 1250 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 5 16 1250 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 18 5 1250 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 6 18 625 vresR1
.model vresR1 r(  )

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 5

*## Multisim Component Q18 ##*
mQ18 14 12 17 17 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q17 ##*
mQ17 17 D0 14 14 PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q16 ##*
mQ16 14 12 16 16 PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q15 ##*
mQ15 16 D0 14 14 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q14 ##*
mQ14 12 D0 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q13 ##*
mQ13 12 D0 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q12 ##*
mQ12 Vout 4 14 14 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q11 ##*
mQ11 14 D1 Vout Vout PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q10 ##*
mQ10 Vout 4 7 7 PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q9 ##*
mQ9 7 D1 Vout Vout NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q8 ##*
mQ8 4 D1 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q7 ##*
mQ7 4 D1 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q6 ##*
mQ6 7 1 5 5 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q5 ##*
mQ5 5 D0 7 7 PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q4 ##*
mQ4 7 1 18 18 PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q3 ##*
mQ3 18 D0 7 7 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

*## Multisim Component Q2 ##*
mQ2 1 D0 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.0009

*## Multisim Component Q1 ##*
mQ1 1 D0 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=0.00018  W=0.00036

.subckt XXMM1_127046952 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos
